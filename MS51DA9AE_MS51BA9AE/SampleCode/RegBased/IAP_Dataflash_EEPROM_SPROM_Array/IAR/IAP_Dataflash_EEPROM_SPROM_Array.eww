<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAP_Dataflash_EEPROM_SPROM_Array.ewp</path>
  </project>
  <batchBuild/>
</workspace>


