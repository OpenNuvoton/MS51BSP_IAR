<?xml version='1.0' encoding='UTF-8'?>
<workspace>
  <project>
    <path>$WS_DIR$\INT1_ExtInt.ewp</path>
  </project>
  <batchBuild />
</workspace>