<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC_IO_Trig.ewp</path>
    </project>
    <batchBuild />
</workspace>
