<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\UART3_TX_RX.ewp</path>
    </project>
    <batchBuild />
</workspace>
