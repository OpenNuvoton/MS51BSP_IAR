<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAP_AP_program_LD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


